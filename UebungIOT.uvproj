# Keil uVision project UebungIOT.uvproj, settings and files
target STM32F429I-DISCO (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: iot_uebung
  c flags: Optim=1 OneElfS=1
  c define: USE_STM32F4XX_NUCLEO, STM32F429xx, USART_PRINT_MSG, USE_HAL_DRIVER, MBEDTLS_CONFIG_FILE=<bluemix_mbedtls_config.h>, USE_MBED_TLS, _UINTPTR_T, MOSQUITTO, BLUEMIX, UINTPTR_T, NIST_GOV, MSG_ERROR, MSG_INFO, MSG_WARNING, SENSOR, IKS01A2, ARM_MATH_CM4, USE_LWIP, __FPU_PRESENT=1U, SENSOR
  c misc: --c99
  c include: .\Projects\STM32F429ZI-Nucleo\Applications\Cloud\Bluemix\Inc;.\Middlewares\ST\lib_nfc\lib_NDEF\inc;.\Projects\Common\fft\inc;.\Drivers\STM32F4xx_HAL_Driver\Inc;.\Drivers\CMSIS\Include;.\Drivers\BSP\X_NUCLEO_NFC04A1;.\Drivers\BSP\STM32F4xx_Nucleo_144;.\Drivers\BSP\Components\ST25DV;.\Middlewares\Third_Party\LwIP\src\include;.\Projects\Common\Shared\Inc;.\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;.\Middlewares\Third_Party\FreeRTOS\Source\include;.\Drivers\BSP\STM32F4xx_Nucleo_144;.\Drivers\BSP\X_NUCLEO_IKS01A2;.\Drivers\CMSIS\Device\ST\STM32f4xx\Include;.\Drivers\BSP\Components\Common;.\Projects\Common\Bluemix\inc;.\Middlewares\Third_Party\mbedTLS\include;.\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\Middlewares\Third_Party\LwIP\system;.\Drivers\BSP\Components\lsm6dsl;.\Middlewares\Third_Party\LwIP\src\include\lwip;.\Drivers\BSP\Components\lsm303agr;.\Drivers\BSP\Components\lis2dh12;.\Drivers\BSP\Components\lis2dw12;.\Drivers\BSP\Components\h3lis331dl;.\Drivers\BSP\Components\lis2mdl;.\Drivers\BSP\Components\hts221;.\Drivers\BSP\Components\lps22hb;.\Middlewares\Third_Party\cmocka\include;.\Projects\STM32F429ZI-Nucleo\Applications\Cloud\Bluemix\Src;.\Middlewares\Third_Party\Bluemix\src;.\Middlewares\Third_Party\cJSON;.\Middlewares\Third_Party\paho.mqtt.embedded-c\MQTTClient-C\src;.\Middlewares\Third_Party\paho.mqtt.embedded-c\MQTTPacket\src;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Drivers\STM32F429ZI_Nucleo_144.sct
  group startup
    ./Drivers/: startup_stm32f429xx.s
  group User
    ./User/: user.c user.h
  group Application
    ./Projects/STM32F429ZI-Nucleo/Applications/Cloud/Bluemix/Src/: app_ethernet.c console.c ethernetif.c flash_f4.c main.c platform_STM32Cube_NucleoF429ZI.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c Watson_LWIP.c
    ./Projects/Common/Bluemix/src/: bluemix.c iotf_network_tls_wrapper.c sensor_def.c
    ./Projects/Common/Shared/Src/: cloud.c entropy_hardware_poll.c firewall_wrapper.c heap.c http_util.c iot_flash_config.c lwip_net.c mbedtls_net.c net.c net_tcp_lwip.c net_tls_mbedtls.c rfu.c sensors_data.c timedate.c timer.c STM32CubeRTCInterface.c timingSystem.c
    ./Projects/Common/fft/src/: Watson_aux.c
  group Drivers
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
    ./Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_accelero.c x_nucleo_iks01a2_gyro.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_magneto.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
    ./Drivers/BSP/STM32F4xx_Nucleo_144/: stm32f4xx_I2C.c stm32f4xx_nucleo_144.c stm32f4xx_UART.c
    ./Drivers/BSP/Components/h3lis331dl/: H3LIS331DL_ACC_driver.c H3LIS331DL_ACC_driver_HL.c
    ./Drivers/BSP/Components/hts221/: HTS221_Driver_HL.c HTS221_Driver.c
    ./Drivers/BSP/Components/lis2dh12/: LIS2DH12_ACC_driver.c LIS2DH12_ACC_driver_HL.c
    ./Drivers/BSP/Components/lis2dw12/: LIS2DW12_ACC_driver.c LIS2DW12_ACC_driver_HL.c
    ./Drivers/BSP/Components/lis2mdl/: LIS2MDL_MAG_driver.c LIS2MDL_MAG_driver_HL.c
    ./Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver_HL.c
    ./Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ./Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c
    ./Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
  group Middlewares
    ./Middlewares/Third_Party/Bluemix/src/: deviceclient.c devicemanagementclient.c iotf_utils.c iotfclient.c
    ./Middlewares/Third_Party/cJSON/: cJSON.c cJSON_Utils.c
    ./Middlewares/Third_Party/cmocka/src/: cmocka.c
    ./Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src/: MQTTClient.c
    ./Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group lwip
    ./Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ./Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
    ./Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group mbedTLS
    ./Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group FreeRTOS
    ./Middlewares/Third_Party/FreeRTOS/Source/: timers.c tasks.c queue.c list.c croutine.c
    ./Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ./Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
